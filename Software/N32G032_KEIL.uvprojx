# Keil uVision project N32G032_KEIL.uvprojx, settings and files
target N32G032 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: N32G032_KEIL +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G032, USE_STDPERIPH_DRIVER
  c include: .\FreeRTOS\Source\include;.\FreeRTOS\Source\portable\MemMang;.\FreeRTOS\Source\portable\RVDS\ARM_CM0;.\FreeRTOS\Source\CMSIS_RTOS;.\USER;.\BSP;.\FWLIB\inc;.\CMSIS\core;.\CMSIS\device
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group USER
    ./USER/: main.c n32g032_it.c my_gpio.c my_gpio.h include.h Config.h FreeRTOSConfig.h touch.c touch.h
  group BSP
    ./BSP/: bsp_adc.c bsp_adc.h bsp_led.c bsp_led.h bsp_motor.c bsp_motor.h mymath.c mymath.h bsp_button.c bsp_button.h bsp_exit.c bsp_exit.h bsp_uart1.c bsp_uart1.h bsp_uart2.c bsp_uart2.h bsp_i2c.c bsp_i2c.h bsp_spi.c bsp_spi.h
  group STARTUP
    ./CMSIS/device/startup/: startup_n32g032.s
  group CMSIS
    ./CMSIS/device/: system_n32g032.c
  group FWLIB
    ./FWLIB/src/: misc.c n32g032_adc.c n32g032_beeper.c n32g032_can.c n32g032_comp.c n32g032_crc.c n32g032_dbg.c n32g032_dma.c n32g032_exti.c n32g032_flash.c n32g032_gpio.c n32g032_hdiv.c n32g032_i2c.c n32g032_iwdg.c n32g032_lptim.c n32g032_lpuart.c n32g032_opamp.c n32g032_pwr.c n32g032_rcc.c n32g032_rtc.c n32g032_spi.c n32g032_sqrt.c n32g032_tim.c n32g032_tsc.c n32g032_usart.c n32g032_wwdg.c
  group FreeRTOS
    ./FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./FreeRTOS/Source/portable/MemMang/: heap_4.c
    ./FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
    ./FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
